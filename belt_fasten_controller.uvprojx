# Keil uVision project belt_fasten_controller.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: belt_fasten_controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: LED.c utilities.c switch.c main.c LED.h switch.h utilities.h Seg_LCD.c Seg_LCD.h
software components: CMSIS:CORE 5.6.0, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:gpio 2.2.1, Device:SDK Drivers:i2c 2.0.5, Device:SDK Drivers:lpsci 2.0.4, Device:SDK Drivers:port 2.0.2, Device:SDK Drivers:smc 2.0.3, Device:SDK Drivers:uart 2.1.5, Device:SDK Utilities:debug_console 1.0.0, Device:Startup 1.0.0
